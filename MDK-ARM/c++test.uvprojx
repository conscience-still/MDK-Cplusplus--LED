# Keil uVision project c++test.uvprojx, settings and files
target c++test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F071VBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: c++test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: STM32F071xB,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,HSI_VALUE=8000000,LSI_VALUE=40000,VDD_VALUE=3300,PREFETCH_ENABLE=1,INSTRUCTION_CACHE_ENABLE=0,DATA_CACHE_ENABLE=0
  c misc: --cpp
  c include: ../Inc;    ../Drivers/STM32F0xx_HAL_Driver/Inc;    ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;    ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f071xb.s
  group Application/User
    ../Src/: stm32f0xx_it.c retarget.c main.cpp
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_gpio.c stm32f0xx_ll_pwr.c stm32f0xx_ll_exti.c stm32f0xx_ll_usart.c stm32f0xx_ll_rcc.c stm32f0xx_ll_dma.c stm32f0xx_ll_utils.c
software components: CMSIS:CORE 5.1.1
